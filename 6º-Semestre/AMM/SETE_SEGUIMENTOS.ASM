	org 0
	JMP INICIO
	DB FB
	DB B
	DB B7
	DB 9F
	DB 4F
	DB DD
	DB FD
	DB 8B
	DB FF
	DB CF
INICIO:
	MOV DL, A
DEC:	MOV CL,A
	MOV BL, 2
	MOV AL, [BL]
	DEC AL
	OUT 2
UNI:	MOV AL, [BL]
	OUT 2
	INC BL
	DEC CL
	JNZ UNI

	DEC DL
	JNZ DEC
	

	END